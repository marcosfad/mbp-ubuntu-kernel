## templates/Kconfig
```kconfig
menuconfig TEST_DRIVER
	tristate "TEST_DRIVER"
  depends on X86 || COMPILE_TEST
	default m
```
